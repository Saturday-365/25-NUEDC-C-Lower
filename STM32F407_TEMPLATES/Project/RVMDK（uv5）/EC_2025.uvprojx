# Keil uVision project EC_2025.uvprojx, settings and files
target STD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EC_2025 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User\Drivers\Key;..\..\User\Drivers\Led;..\..\User\Drivers\Exit;..\..\User\Drivers\Systick;..\..\User\Drivers\Buzzer;..\..\User\Drivers\Usart;..\..\User\Drivers\I2C;..\..\User\Drivers\Flash;..\..\User\Drivers\Adc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c delay.c delay.h
  group Drivers
    ../../User/Drivers/Key/: bsp_key.c bsp_key.h
    ../../User/Drivers/led/: bsp_led.c bsp_led.h
    ../../User/Drivers/Exit/: bsp_exit.c bsp_exit.h
    ../../User/Drivers/Systick/: bsp_systick.c bsp_systick.h
    ../../User/Drivers/Buzzer/: bsp_Buzzer.c bsp_Buzzer.h
    ../../User/Drivers/Usart/: bsp_Usart.c bsp_Usart.h HMI.c HMI.h
    ../../User/Drivers/I2C/: bsp_iic_ee.c bsp_iic_ee.h
    ../../User/Drivers/Flash/: bsp_spi_Flash.c bsp_spi_Flash.h
    ../../User/Drivers/Adc/: bsp_Adc.c bsp_Adc.h
  group DOC
    ../../: 必读说明.txt
