# Keil uVision project Blinky.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407IGHx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407IGHx/STCubeGenerated/Inc/: stm32f4xx_it.h
target Release (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: as above
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Board Support:Buttons 2.0.0, Board Support:LED 2.0.0, Device:STM32Cube HAL:ADC 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:Startup 2.6.3
