# Keil uVision project GUIDemo.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0-dev2
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GUIDemo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM TS_LANDSCAPE=1 USE_STM32469I_DISCO_REVB
  c include: .\
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
    ./: GUIDemo.c
  group Documentation
    ./: Abstract.txt
target Release (6190000::V6.19::ARMCLANG)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0-dev2
  cpu: as above
  output: GUIDemo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c include: .\
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Board Support:Components:FT6X06 1.1.0, Board Support:Components:NT35510 1.0.0, Board Support:Components:OTM8009A 1.0.4, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:SDRAM 1.0.0, Board Support:Drivers:Touch Screen 1.0.0, Board Support:Touchscreen 1.0.0, Board Support:emWin LCD 1.0.0, Compiler:Event Recorder 1.4.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:DMA2D 1.7.13, Device:STM32Cube HAL:DSI 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:I2C 1.7.13, Device:STM32Cube HAL:LTDC 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SDRAM 1.7.13, Device:STM32Cube HAL:SPI 1.7.13, Device:Startup 2.6.3, Graphics Display:32F469IDISCOVERY 1.0.0, Graphics:CORE 6.16.3, Graphics:Demo:AntialiasedText 6.16.3, Graphics:Demo:Automotive 6.16.3, Graphics:Demo:BarGraph 6.16.3, Graphics:Demo:Bitmap 6.16.3, Graphics:Demo:ColorBar 6.16.3, Graphics:Demo:Cursor 6.16.3, Graphics:Demo:Fading 6.16.3, Graphics:Demo:Framework 6.16.3, Graphics:Demo:Graph 6.16.3, Graphics:Demo:IconView 6.16.3, Graphics:Demo:ListView 6.16.3, Graphics:Demo:RadialMenu 6.16.3, Graphics:Demo:Skinning 6.16.3, Graphics:Demo:Speed 6.16.3, Graphics:Demo:TransparentDialog 6.16.3, Graphics:Demo:Treeview 6.16.3, Graphics:Demo:WashingMachine 6.16.3, Graphics:Input Device:Touchscreen 6.16.3
