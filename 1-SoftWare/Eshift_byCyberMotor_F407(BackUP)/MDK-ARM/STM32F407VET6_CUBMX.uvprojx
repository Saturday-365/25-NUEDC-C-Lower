# Keil uVision project STM32F407VET6_CUBMX.uvprojx, settings and files
target STM32F407VET6_CUBMX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407VET6_CUBMX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Sourse_Library/1_SA_Library;../Sourse_Library/2_SA_peripheral;../Sourse_Library/3_SA_Starup;../Sourse_Library/4_XMCyberGear_Libary
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/User/Core
    ./: startup_stm32f407xx.s
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group SA_Library
    ../Sourse_Library/1_SA_Library/: SA_Delay.c SA_Delay.h SA_Flash.c SA_Flash.h SA_karman.c SA_karman.h SA_Key.c SA_Key.h SA_Usart.c SA_Usart.h
  group SA_CZCD
    ../Sourse_Library/1_SA_Library/: SA_E_Shift.c SA_E_Shift.h SA_CANDataprocess.c SA_CANDataprocess.h
  group SA_starup
    ../Sourse_Library/3_SA_Starup/: common.c common.h
    ../Sourse_Library/1_SA_Library/: headfile.h
  group XMCyberGear_Libary
    ../Sourse_Library/4_XMCyberGear_Libary/: CyberGear_Control.c CyberGear_Control.h xiaomi_driver.h
  group SA_peripheral
    ../Sourse_Library/2_SA_peripheral/: ATK_UART.c ATK_UART.h
software components: CMSIS:CORE 4.3.0
